# Keil uVision project Project.uvprojx, settings and files
target STM32F429I-Discovery (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F429ZITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.0
  cpu: IRAM(0x20000000-0x2002FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x81FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F429I-Discovery
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,USE_STM32F429I_DISCOCUSTOM_DEFINE SYS_CORTEX_M4 DEV_STM32_F429_DISCO USE_KEIL
  c misc: --C99
  c include: ..\Inc;..\..\Stm32Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\Stm32Drivers\STM32F4xx_HAL_Driver\Inc;..\..\Stm32Drivers\BSP\STM32F429I-Discovery;MY_SEP;..\..\..\..\MCUToken\iot_client\app\;..\..\..\..\MCUToken\iot_client\fp_gen\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  link misc: --diag_suppress=L6329
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c
  group Example/MDK-ARM
    ./: startup_stm32f429xx.s
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group Drivers/BSP/STM32F429I-Discovery
    ../../Stm32Drivers/BSP/STM32F429I-Discovery/: stm32f429i_discovery.c
  group app
    ../../../../MCUToken/iot_client/app/: adc.h app_port.h dac.h defs.h flash_internal.h iwdg.h pwm.h rtc.h shell.h timer.h usart.h utils.h adc.c app_port.c dac.c flash_internal.c iwdg.c pwm.c rtc.c shell.c shell_cmds.c timer.c usart.c utils.c device_data.c device_data.h aes.h base64.c base64.h
  group fp_gen
    ../../../../MCUToken/iot_client/fp_gen/: fp_gen.h fp_gen.c task_clock.c task_fpu.c task_init.c task_store.c task_voltage.c token_gen.c dev_reg.c
    ../../../../MCUToken/iot_client/app/: aes.c aes.h
  group STM32F4-HAL
    ../../Stm32Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_i2c.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_usart.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_spi.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c
software components: CMSIS:CORE 4.1.0
